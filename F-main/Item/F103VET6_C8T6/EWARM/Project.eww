<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F103VET6_Usart_time.ewp</path>
  </project>
  <batchBuild />
</workspace>
